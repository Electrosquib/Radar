options:
  parameters:
    author: Levi Farinas
    generate_options: qt_gui
    id: pilot_chirp
    output_language: python
    title: Chirp with Pilot Tone
  states: {}

blocks:
- name: bb_chirp_period
  id: variable
  parameters:
    value: '50e-6'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: chirp_bw
  id: variable
  parameters:
    value: .8 * (sdr_fs/2)
  states: {}
- name: chirp_idx
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pilot_amplitude
  id: variable
  parameters:
    value: '.2'
  states: {}
- name: pilot_bb_freq
  id: variable
  parameters:
    value: sdr_fs/2 * .9
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: sdr_fs
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: usrp_string
  id: variable
  parameters:
    value: '""'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2*3.14159*chirp_bw)/(sdr_fs)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/bb_chirp_period
    maxoutbuf: '100'
    offset: '0'
    phase: '3.14159'
    samp_rate: sdr_fs
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: pilot_amplitude
    freq: pilot_bb_freq
    offset: '0'
    phase: '0'
    samp_rate: sdr_fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(bb_chirp_period*sdr_fs)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: sdr_fs
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: f"/Users/levifarinas/Dropbox/University/SAR Research/Data/pilot_chirp_{chirp_idx}.wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: sdr_fs
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: f"/Users/levifarinas/Dropbox/University/SAR Research/Data/rx_{chirp_idx}.wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: sdr_fs
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_fs
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: usrp_string
    gain0: rf_gain
    samp_rate: sdr_fs
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '60'
    samp_rate: sdr_fs
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_wavfile_sink_0_0, '1']
- [blocks_head_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', analog_frequency_modulator_fc_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
