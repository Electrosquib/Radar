options:
  parameters:
    author: Levi Farinas
    generate_options: no_gui
    id: continuous_chirp
    output_language: python
    run_options: run
    title: continuous_chirp
  states: {}

blocks:
- name: c
  id: variable
  parameters:
    value: 3e8
  states: {}
- name: chirp_bw
  id: variable
  parameters:
    value: .8 * (sdr_fs)
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653'
  states: {}
- name: pilot_bb_freq
  id: variable
  parameters:
    value: (sdr_fs/2) * .9
  states: {}
- name: postchirp_buffer
  id: variable
  parameters:
    value: int(1e3)
  states: {}
- name: prechirp_buffer
  id: variable
  parameters:
    value: int(10e3)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: mask
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2*3.14159*chirp_bw)/(sdr_fs)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/bb_chirp_period
    maxoutbuf: '100'
    offset: pi
    phase: pi
    samp_rate: sdr_fs
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: pilot_amplitude
    freq: pilot_bb_freq
    offset: '0'
    phase: '0'
    samp_rate: sdr_fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bb_chirp_period
  id: parameter
  parameters:
    type: eng_float
    value: '1e-3'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mask
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: sdr_fs
    type: float
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /Users/levifarinas/Documents/SAR Research/Data/sweep.wav
    format: FORMAT_WAV
    nchan: '5'
    samp_rate: sdr_fs
  states: {}
- name: center_freq
  id: parameter
  parameters:
    type: eng_float
    value: 2.5e9
  states: {}
- name: mask
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pilot_amplitude
  id: parameter
  parameters:
    type: eng_float
    value: '.2'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '.7'
  states: {}
- name: sdr_fs
  id: parameter
  parameters:
    type: intx
    value: int(4e6)
  states: {}
- name: subchirp_idx
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: sdr_fs
    center_freq0: center_freq
    gain0: tx_gain
    gain_type0: normalized
    samp_rate: sdr_fs
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: sdr_fs
    center_freq0: center_freq
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: sdr_fs
    sync: sync
    type: fc32
  states: {}
- name: usrp_string
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_wavfile_sink_1, '2']
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_1, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_1, '1', blocks_wavfile_sink_1, '1']
- [blocks_complex_to_float_1_0, '0', blocks_wavfile_sink_1, '3']
- [blocks_complex_to_float_1_0, '1', blocks_wavfile_sink_1, '4']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', analog_frequency_modulator_fc_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
